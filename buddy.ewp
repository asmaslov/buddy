# IAR project buddy.ewp, settings and files
configuration Debug_sram (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM7X256 Atmel AT91SAM7X256
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: sram; TRACE_LEVEL=TRACE_LEVEL_DEBUG; NOFPUT
  ICCARM.CCIncludePath2: ; boards\sam7-ex256; periphery; drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: sram
  AARM.AUserIncludes: ; boards\sam7-ex256
  OBJCOPY.OOCOutputFile: buddy.bin
  ILINK.IlinkOutputFile: sram.out
  ILINK.IlinkIcfFile: boards\sam7-ex256\sram.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration Release_flash (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: flash; TRACE_LEVEL=TRACE_LEVEL_NO_TRACE; NOASSERT; NOFPUT
  AARM.ADefines: flash
  ILINK.IlinkOutputFile: flash.out
  ILINK.IlinkIcfFile: boards\sam7-ex256\flash.icf
  group Application
    ./: bender.h commander.c comvault.c debugport.c main.c manipulator.c parser.c protocol.h
  group Application/Drivers
    drivers/: adcd.c i2cd.c lcd.c pwmcd.c tcd.c usartd.c
  group Application/Drivers/Headers
    drivers/: adcd.h i2cd.h lcd.h pwmcd.h tcd.h usartd.h
  group Application/Headers
    ./: commander.h comvault.h debugport.h manipulator.h parser.h
  group Board
    boards/sam7-ex256/: AT91SAM7X256.h board.h board_cstartup.s board_lowlevel.c board_memories.c board_memories.h
  group Periphery
    periphery/: adc.c aic.c dbgu.c pio.c pit.c pmc.c pwmc.c spi.c tc.c twi.c usart.c
  group Periphery/Headers
    periphery/: adc.h aic.h dbgu.h pio.h pit.h pmc.h pwmc.h spi.h tc.h twi.h usart.h
  group Tools
    periphery/: assert.h async.h delay.c smplmath.c trace.h
    ./: bits.h
  group Tools/Headers
    periphery/: delay.h smplmath.h
